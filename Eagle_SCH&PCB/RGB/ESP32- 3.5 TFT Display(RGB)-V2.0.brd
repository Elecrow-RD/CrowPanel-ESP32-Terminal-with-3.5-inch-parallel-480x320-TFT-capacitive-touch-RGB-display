# Repository Elecrow-RD/CrowPanel-ESP32-Terminal-with-3.5-inch-parallel-480x320-TFT-capacitive-touch-RGB-display

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V2.0     | V1.0     | latest |

### 3, product information

- ESP32-S3WROOM-1-N16R8 module with 16MB Flash and 8 MB PSRAM
- Wi-Fi Protocol: 802.11b/g/n (802.11n up to 150Mbps)
- Wi-Fi Frequency Range: 2.402GHz - 2.483Ghz
- Support Bluetooth 5
- With 4 Crowtail interfaces (HY2.0-4P connector) and on-board Micro TF card slot
- 3.5-inch TFT LCD RGB true color LCD screen with 480*320 resolution
- Driver chip: ILI9488 (16-bit parallel line)
- Capacitive touch panel controller IC FT6236 series
- Operating Voltage: DC 5V, 500mA
- Operating temperature: -10°C ~ 65°C
- Active Area: 73.63(L)x49.79mm(W)
- Appearance Dimensions: 106(L)x66mm(W)x13mm(H)

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

##### ESP-IDF starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the IDF plug-in, select the port, then compile and flash

##### PlatformIO starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the PlatformIO plug-in, select the port, then compile and flash

##### Micropython starts

1,Right-click on an empty space in the project folder and select "Thonny" to open the project.

2,In thonny software, select the master and port, then run the program

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

        cfg.pin_wr = 18;
        cfg.pin_rd = 48;
        cfg.pin_rs = 45;
        cfg.pin_d0 = 47;
        cfg.pin_d1 = 21;
        cfg.pin_d2 = 14;
        cfg.pin_d3 = 13;
        cfg.pin_d4 = 12;
        cfg.pin_d5 = 11;
        cfg.pin_d6 = 10;
        cfg.pin_d7 = 9;
        cfg.pin_d8 = 3;
        cfg.pin_d9 = 8;
        cfg.pin_d10 = 16;
        cfg.pin_d11 = 15;
        cfg.pin_d12 = 7;
        cfg.pin_d13 = 6;
        cfg.pin_d14 = 5;
        cfg.pin_d15 = 4;
#define SDA_FT6236 38

#define SCL_FT6236 39

## EAGLE design Eagle_SCH&PCB/RGB/ESP32- 3.5 TFT Display(RGB)-V2.0.brd

Parts:
B1: MLT-8530
BAT: CON-80-2P-M; 2P-2.0-M
BOOT: BUTTON; 157SW
C1, C4, C6, C7, C9, C11, C12, C13, C20, C23: 100nF; C0603
C2, C3, C16, C17, C18, C19, C30, C31, C33, C34, C39, C41: 10uF; 0805_S
C5, C32: 47uF/10v; AVX-B
C8, C10, C14: 1uF; C0603
C15: 0.1uF; DISCRETE_C0603
C21, C27, C28, C35, C36, C43: 22uF; 0805
C22: 1uF; 0603
C26, C29: 100nF; 0603
C38: 100nF; DISCRETE_C0603
C40: 0.1uF; 0603
CHR: RED; LED-0603
D3: IN5817; DO-214AC
D4: 1N5819WS; SOD-323
D5: SS34; DO-214AC
D24: SS34B/SMB; 214AB
J1, J2, J3, J5: TWIG-4P-2.0-SMD-FEMALE-REINFORCE'90D'; 4P-SMD-2.0-90D
J4: KEVIN_TYPEC-3.0-16P-SMD; KEVIN_3.0TYPEC-SMD
J14: SD Card; 9P-SMD-W/-RING
L6: 33UH; L773
L14: CD32_950MA; CD32
LCD: TFT-40P-3.5; TFT-3.5寸40PIN
P1, P3, P4, P5, P6, P10, P11, P12, P13: PADPAD-1.0MM; PAD-1.0MM
P2: AFC01-S06FCC-00; SMD8-50P-740L535W
PWR: Green; LED-0603
Q1: NMOS7002; SOT23
Q2, Q9, Q10: S9013; SOT23@1
Q3: PMOS-3401-4A; SOT-23
Q4, Q5, Q6, Q7, Q8: BSN20; SOT23
R1, R6, R7, R11, R12, R13: 0R; R0603
R2, R3: 100K; DISCRETE_R0603
R4, R5, R58: NC; R0603
R8: 2K; R0603
R9: 2K; DISCRETE_R0603
R10, R27, R42, R44, R53, R54, R55, R56, R57, R59, R60: 10k; R0603
R17, R18: 5.1K; DISCRETE_R0603
R19, R24, R43, R51: 10K; DISCRETE_R0603
R21, R22, R23: 10R; R0603
R25, R46, R74, R75: 1K; DISCRETE_R0603
R28, R33, R37, R38, R40: 47K; R0603
R35, R52: NC; DISCRETE_R0603
R36: 22K 1%; R0603
R41: 100K 1%; R0603
R45: 5.1R; R0603
R48: 20K; DISCRETE_R0603
R49: 0R; DISCRETE_R0603
R50: 73.2K; DISCRETE_R0603
R71: 22R; DISCRETE_R0603
R72: 470R; DISCRETE_R0603
RESET: BUTTON; 157SW
SM: TFT-3.5; LCD3.5寸
T1, T2: 3M-5
U1: HM1548C; A_XBJ_SOT23-6
U2: ESP32-S; ESP32-S3
U3: STC8G1K08; DFN8
U6: CH340C; SOP-16
U8: NC\NS2009; MSOP10
U26: 4054A; SOP23-5
U41: HX3406; SOT23-5

Connections:
+5V: C17.2, C18.2, C21.2, C27.2, C29.2, C35.2, C41.2, D24.2 (-), J1.3, J2.3, J3.3, P4.P$1, R44.2, R50.1, R53.2, R54.2, R57.2, R59.2
BAT+: BAT.1, C2.2, C3.2, D3.A, Q3.3 (D), R3.2, U26.3 (BAT)
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN: C14.1, LCD.15 (RESET), P2.5, Q9.3 (C), R19.1, RESET.1, U2.3 (EN)
GHRG: R4.2, R18.2, U3.7 (P3.2/SCLK), U26.1 (GHRG)
GND: BAT.2, BAT.3, BAT.4, BOOT.2, C1.1, C2.1, C3.1, C4.1, C5.-, C6.2, C7.2, C8.2, C9.1, C10.2, C11.1, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.2, C26.2, C27.1, C28.1, C29.1, C30.1, C31.1, C32.-, C33.1, C34.1, C35.1, C36.1, C38.1, C39.1, C40.2, C41.1, C43.1, J1.4, J1.SS1, J1.SS2, J2.4, J2.SS1, J2.SS2, J3.4, J3.SS1, J3.SS2, J4.A1, J4.A12, J4.B1, J4.B12, J4.P$1, J4.P$2, J4.P$3, J4.P$4, J4.P$5, J5.4, J5.SS1, J5.SS2, J14.6 (VSS), J14.G1, J14.G2, J14.G3, J14.G4, LCD.5 (GND), LCD.13 (SPI_SDA), LCD.16 (GND1), LCD.37 (GND2), P2.6, P2.7, P2.8, P13.P$1, PWR.-, Q1.2 (S), Q2.2 (E)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
GPIO0: BOOT.1, Q10.3 (C), R35.1, U2.27 (IO0)
GPIO1-CS: J14.2 (CS), R37.1, U2.39 (IO1)
GPIO2-MOSI: J14.3 (DI), R38.1, U2.38 (IO2)
GPIO3-DB8: LCD.25 (DB8), U2.15 (IO3)
GPIO4-DB15: LCD.32 (DB15), U2.4 (IO4)
GPIO5-DB14: LCD.31 (DB14), U2.5 (IO5)
GPIO6-DB13: LCD.30 (DB13), U2.6 (IO6)
GPIO7-DB12: LCD.29 (DB12), U2.7 (IO7)
GPIO8-DB9: LCD.26 (DB9), U2.12 (IO8)
GPIO9-DB7: LCD.24 (DB7), U2.17 (IO9)
GPIO10-DB6: LCD.23 (DB6), U2.18 (IO10)
GPIO11-DB5: LCD.22 (DB5), U2.19 (IO11)
GPIO12-DB4: LCD.21 (DB4), U2.20 (IO12)
GPIO13-DB3: LCD.20 (DB3), U2.21 (IO13)
GPIO14-DB2: LCD.19 (DB2), U2.22 (IO14)
GPIO15-DB11: LCD.28 (DB11), U2.8 (IO15)
GPIO16-DB10: LCD.27 (DB10), U2.9 (IO16)
GPIO17: C1.2, R2.2, R3.1, U2.10 (IO17)
GPIO18: LCD.11 (WR/SPI_SCL), U2.11 (IO18)
GPIO20_BUZZER: R46.1, U2.14 (IO20)
GPIO21-DB1: LCD.18 (DB1), U2.23 (IO21)
GPIO38-SDA: P2.2, Q4.2 (S), R42.2, U2.31 (IO38), U8.9 (SDA)
GPIO38-SDA-: J2.2, Q4.3 (D), R53.1
GPIO39-SCL: P2.3, Q5.2 (S), R55.1, U2.32 (IO39), U8.10 (SCL)
GPIO39-SCL-: J2.1, Q5.3 (D), R54.1
GPIO40: Q6.2 (S), R56.1, R58.1, U2.33 (IO40)
GPIO40-: J3.1, Q6.3 (D), R57.1, R58.2
GPIO41-MISO: J14.7 (DO), R40.1, U2.34 (IO41)
GPIO42-SCLK: J14.5 (SCLK), U2.35 (IO42)
GPIO45: LCD.10 (RS/SPI_AO), U2.26 (IO45)
GPIO46: R10.1, U2.16 (IO46)
GPIO47-DB0: LCD.17 (DB0), U2.24 (IO47)
GPIO48-RD: LCD.12 (RD), U2.25 (IO48)
GPIO-19: J5.1, U2.13 (IO19)
IM0: LCD.38 (IM0), R11.2
IM1: LCD.39 (IM1), R5.2, R13.1
IM2: LCD.40 (IM2), R7.2
K: Q1.3 (D), R21.1, R22.1, R23.1
LED: R17.2, U3.8 (P3.3/MISO)
unnamed: Q1.1 (G), R10.2
unnamed: J14.1 (DATA2), R28.2
unnamed: PWR.+, R8.1
unnamed: LCD.34 (K1), R21.2
unnamed: LCD.35 (K2), R22.2
unnamed: B1.2 (-), D4.2 (+), Q2.3 (C)
unnamed: LCD.36 (K3), R23.2
unnamed: LCD.9 (CS/SPI_CS), R1.1
unnamed: CHR.-, R4.1, R17.1
unnamed: D24.1 (+), L6.2, U1.1 (1-SW)
unnamed: B1.1 (+), D4.1 (-), R45.2
unnamed: R9.1, U26.5 (PROG)
unnamed: P11.P$1, R6.2, U3.6 (P3.1/TXD)
unnamed: Q3.1 (G), R24.2, R25.1
unnamed: P12.P$1, R12.2, U3.5 (P3.0/RXD)
unnamed: J14.8 (DATA1), R33.2
unnamed: R49.2, R52.1, U8.8 (A0)
unnamed: L14.1, U41.3 (LX)
unnamed: R50.2, R51.1, U1.3 (3-FB)
unnamed: R48.2, U1.6 (6-NC)
unnamed: Q9.1 (B), R75.1
unnamed: R36.2, R41.1, U41.5 (BF)
unnamed: Q2.1 (B), R46.2
unnamed: Q10.1 (B), R74.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
PENI: P2.4, R35.2, R43.1, U8.7 (PENIRQ)
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
RXD: J4.A5, J4.B5, R12.1
TXD: J4.A8, J4.B8, R6.1
UART0_RXD0: Q8.2 (S), R60.1, R72.1, U2.36 (RXD0)
UART0_RXD0-: J1.1, Q8.3 (D), R59.1
UART0_TXD0: Q7.2 (S), R27.2, R71.1, U2.37 (TXD0)
UART0_TXD0-: J1.2, Q7.3 (D), R44.1
USB_DN: J4.A7, J4.B7, U6.6 (UD-)
USB_DP: J4.A6, J4.B6, U6.5 (UD+)
VBUS: C19.2, C20.1, C23.1, CHR.+, D5.A, J4.A4, J4.A9, J4.B4, J4.B9, P10.P$1, R18.1, R25.2, U3.2 (VCC), U26.4 (VCC)
VCC_3V3: C4.2, C5.+, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C12.1, C13.1, C15.2, C26.1, C28.2, C30.2, C31.2, C32.+, C33.2, C34.2, C38.2, C39.2, J5.3, J14.4 (VDD), L14.2, LCD.6 (VCC3.3V-1), LCD.7 (VCC3.3V-2), LCD.33 (A), P2.1, Q4.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), R8.2, R13.2, R19.2, R27.1, R28.1, R33.1, R37.2, R38.2, R40.2, R41.2, R42.1, R43.2, R45.1, R52.2, R55.2, R56.2, R60.2, U2.2 (3V3), U6.4 (V3), U6.16 (VCC), U8.1 (VDD)
VIN: C16.2, C22.2, C36.2, C40.1, C43.2, D3.C, D5.C, L6.1, Q3.2 (S), U1.4 (4-SHDN), U1.5 (5-VIN), U41.1 (CE), U41.4 (VIN)
XL: LCD.1 (XL(X-)), U8.4 (XN)
XR: LCD.3 (XR(X+)), U8.2 (XP)
YD: LCD.4 (YD(Y+)), U8.3 (YP)
YU: LCD.2 (XU(Y-)), U8.5 (YN)

Notes on the sheet:
USB转串口
USB-C
TF Card
FT6236
NS2009
POWER
ESP-32
TFT-3.5寸屏
500mA
STC8G1K08
BAT
I2C、 GPIO端口
Vout=0.6*(R6/R5 +1)=5V
5V电源电路
蜂鸣器

Board: 2 copper layers, 105.8 x 65.9 mm, 142 parts (1 on the bottom side), 88 nets.

Other parts of the board:
U$27: LOGO
U$53: TOP-SMT-ESP32
